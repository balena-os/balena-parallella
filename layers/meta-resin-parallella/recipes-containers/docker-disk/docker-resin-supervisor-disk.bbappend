LED_FILE_parallella-hdmi-resin = "/sys/class/leds/CR10/brightness"
